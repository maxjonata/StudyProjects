#include <stdio.h>
#include <stdlib.h>


void showGrade(const char dias,const char horarios,const char tamanhoNome, char table[dias][horarios][tamanhoNome])
{

    system("cls");
    //table[dia][horario]
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][0],table[1][0],table[2][0],table[3][0],table[4][0]);
    printf("\n||                  07:10~08:00 ||                  07:10~08:00 ||                  07:10~08:00 ||                  07:10~08:00 ||                  07:10~08:00 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][1],table[1][1],table[2][1],table[3][1],table[4][1]);
    printf("\n||                  08:00~08:50 ||                  08:00~08:50 ||                  08:00~08:50 ||                  08:00~08:50 ||                  08:00~08:50 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][2],table[1][2],table[2][2],table[3][2],table[4][2]);
    printf("\n||                  08:50~09:40 ||                  08:50~09:40 ||                  08:50~09:40 ||                  08:50~09:40 ||                  08:50~09:40 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][3],table[1][3],table[2][3],table[3][3],table[4][3]);
    printf("\n||                  09:50~10:40 ||                  09:50~10:40 ||                  09:50~10:40 ||                  09:50~10:40 ||                  09:50~10:40 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][4],table[1][4],table[2][4],table[3][4],table[4][4]);
    printf("\n||                  10:40~11:30 ||                  10:40~11:30 ||                  10:40~11:30 ||                  10:40~11:30 ||                  10:40~11:30 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
    printf("\n||%30s||%30s||%30s||%30s||%30s||", table[0][5],table[1][5],table[2][5],table[3][5],table[4][5]);
    printf("\n||                  11:30~12:20 ||                  11:30~12:20 ||                  11:30~12:20 ||                  11:30~12:20 ||                  11:30~12:20 ||");
    printf("\n||------------------------------||------------------------------||------------------------------||------------------------------||------------------------------||");
}

int main()
{
    const char periodos = 10;
    const char dias = 5;
    const char horarios = 6;
    const char tamanhoNome =  30;
    char table[periodos][dias][horarios][tamanhoNome];
    char qtdEscolhas = 1, escolha, i, periodosUsados = 2;

    do{
        system("cls");
        printf("||------------------------------||");
        printf("||  1 - Mostrar periodo         ||");
        printf("||  0 - Sair                    ||");
        printf("||------------------------------||");
        scanf(" %i", &escolha);
    } while(escolha < 0 || escolha > qtdEscolhas);

    switch(escolha)
    {
        case 1:
            do
            {
                system("cls");
                printf("Escolha o período que gostaria de ver a grade montada. (0 ~ 10)");
                printf("            (ATENCAO - escolhendo 0 pode ficar confuso de ler.)");
                printf("                          (Escolha 0 para ver todas)           ");
                printf("> ");
                scanf(" %i", &escolha);
            } while(escolha < 0 || escolha > 10);
            switch(escolha)
            {
                case 0:
                    for(i = 0 ; i < periodosUsados ; i++)
                    {
                        showGrade(dias, horarios, tamanhoNome, table[i]);
                    }
            }
            break;
    }
}